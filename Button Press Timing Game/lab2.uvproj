# Keil uVision project lab2.uvproj, settings and files
target lab2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: lab2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,USE_STDPERIPH_DRIVER STM32F4XX
  c include: .\inc;..\STM32F429I-Discovery_FW_V1.0.1\Libraries\CMSIS\Include;..\STM32F429I-Discovery_FW_V1.0.1\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\STM32F429I-Discovery_FW_V1.0.1\Libraries\CMSIS\Device\ST\STM32F4xx\Source;..\STM32F429I-Discovery_FW_V1.0.1\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\STM32F429I-Discovery_FW_V1.0.1\Libraries\STM32F4xx_StdPeriph_Driver\src;..\STM32F429I-Discovery_FW_V1.0.1\Utilities\STM32F429I-Discovery;..\STM32F429I-Discovery_FW_V1.0.1\Utilities\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../STM32F429I-Discovery_FW_V1.0.1/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rng.c
    ./src/: main.c stm32f4xx_it.c system_stm32f4xx.c eeprom.c
    ./inc/: main.h stm32f4xx_conf.h stm32f4xx_it.h eeprom.h
  group MDK-ARM
    ./: startup_stm32f429_439xx.s
  group Drivers
    ../STM32F429I-Discovery_FW_V1.0.1/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_flash.c
  group Discovery
    ../STM32F429I-Discovery_FW_V1.0.1/Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery.h stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.h
